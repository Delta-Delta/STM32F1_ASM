# Keil uVision project ISP_2K.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103VB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ISP_2K
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Src
  memory RVCT4: ROM 0x8000000 size 0x800
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ./Src/: main.c
    ./: startup.s
